# Keil uVision project ucos3_1.uvprojx, settings and files
target uCOS3 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos3_1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\APP;.\uC-CPU;.\uC-LIB;.\uCOS-III\Ports;.\uCOS-III\Source;.\uCOSIII-BSP;.\uCOSIII-Cfg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./APP/: app.c stm32f10x_it.c os_app_hooks.c includes.h ZPH01.C
  group uC-LIB
    ./uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uC-CPU
    ./uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uCOSIII-BSP
    ./uCOSIII-BSP/: bsp.c bsp_int.c Peripherals_Cfg.c Peripherals_Cfg.h
  group uCOSIII-Source
    ./uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOSIII-Ports
    ./uCOS-III/Ports/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group uCOSIII-Cfg
    ./uCOSIII-Cfg/: cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
